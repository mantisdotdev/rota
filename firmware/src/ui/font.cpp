#include "ui/font.h"

#include <cstring>

namespace ui {

namespace {

struct Glyph {
  char code;
  const char* rows[kGlyphHeight];  // '#' is a lit pixel
};

// clang-format off
const Glyph kGlyphs[] = {
    {' ', {"     ", "     ", "     ", "     ", "     ", "     ", "     "}},
    {'%', {"##   ", "##  #", "   # ", "  #  ", " #   ", "#  ##", "   ##"}},
    {',', {"     ", "     ", "     ", "     ", " ##  ", "  #  ", " #   "}},
    {'-', {"     ", "     ", "     ", "#####", "     ", "     ", "     "}},
    {'.', {"     ", "     ", "     ", "     ", "     ", " ##  ", " ##  "}},
    {':', {"     ", " ##  ", " ##  ", "     ", " ##  ", " ##  ", "     "}},
    {'~', {"     ", "     ", " #  #", "# # #", "#  # ", "     ", "     "}},
    {'0', {" ### ", "#   #", "#  ##", "# # #", "##  #", "#   #", " ### "}},
    {'1', {"  #  ", " ##  ", "  #  ", "  #  ", "  #  ", "  #  ", " ### "}},
    {'2', {" ### ", "#   #", "    #", "   # ", "  #  ", " #   ", "#####"}},
    {'3', {"#####", "   # ", "  #  ", "   # ", "    #", "#   #", " ### "}},
    {'4', {"   # ", "  ## ", " # # ", "#  # ", "#####", "   # ", "   # "}},
    {'5', {"#####", "#    ", "#### ", "    #", "    #", "#   #", " ### "}},
    {'6', {"  ## ", " #   ", "#    ", "#### ", "#   #", "#   #", " ### "}},
    {'7', {"#####", "    #", "   # ", "  #  ", " #   ", " #   ", " #   "}},
    {'8', {" ### ", "#   #", "#   #", " ### ", "#   #", "#   #", " ### "}},
    {'9', {" ### ", "#   #", "#   #", " ####", "    #", "   # ", " ##  "}},
    {'A', {" ### ", "#   #", "#   #", "#####", "#   #", "#   #", "#   #"}},
    {'B', {"#### ", "#   #", "#   #", "#### ", "#   #", "#   #", "#### "}},
    {'C', {" ### ", "#   #", "#    ", "#    ", "#    ", "#   #", " ### "}},
    {'D', {"###  ", "#  # ", "#   #", "#   #", "#   #", "#  # ", "###  "}},
    {'a', {"     ", "     ", " ### ", "    #", " ####", "#   #", " ####"}},
    {'b', {"#    ", "#    ", "# ## ", "##  #", "#   #", "#   #", "#### "}},
    {'c', {"     ", "     ", " ### ", "#    ", "#    ", "#   #", " ### "}},
    {'d', {"    #", "    #", " ## #", "#  ##", "#   #", "#   #", " ####"}},
    {'e', {"     ", "     ", " ### ", "#   #", "#####", "#    ", " ### "}},
    {'f', {"  ## ", " #  #", " #   ", "###  ", " #   ", " #   ", " #   "}},
    {'g', {"     ", "     ", " ####", "#   #", " ####", "    #", " ### "}},
    {'h', {"#    ", "#    ", "# ## ", "##  #", "#   #", "#   #", "#   #"}},
    {'i', {"  #  ", "     ", " ##  ", "  #  ", "  #  ", "  #  ", " ### "}},
    {'j', {"   # ", "     ", "  ## ", "   # ", "   # ", "#  # ", " ##  "}},
    {'k', {" #   ", " #   ", " #  #", " # # ", " ##  ", " # # ", " #  #"}},
    {'l', {" ##  ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", " ### "}},
    {'m', {"     ", "     ", "## # ", "# # #", "# # #", "#   #", "#   #"}},
    {'n', {"     ", "     ", "# ## ", "##  #", "#   #", "#   #", "#   #"}},
    {'o', {"     ", "     ", " ### ", "#   #", "#   #", "#   #", " ### "}},
    {'p', {"     ", "     ", "#### ", "#   #", "#### ", "#    ", "#    "}},
    {'q', {"     ", "     ", " ####", "#   #", " ####", "    #", "    #"}},
    {'r', {"     ", "     ", "# ## ", "##  #", "#    ", "#    ", "#    "}},
    {'s', {"     ", "     ", " ### ", "#    ", " ### ", "    #", "#### "}},
    {'t', {" #   ", " #   ", "###  ", " #   ", " #   ", " #  #", "  ## "}},
    {'u', {"     ", "     ", "#   #", "#   #", "#   #", "#  ##", " ## #"}},
    {'v', {"     ", "     ", "#   #", "#   #", "#   #", " # # ", "  #  "}},
    {'w', {"     ", "     ", "#   #", "#   #", "# # #", "# # #", " # # "}},
    {'x', {"     ", "     ", "#   #", " # # ", "  #  ", " # # ", "#   #"}},
    {'y', {"     ", "     ", "#   #", "#   #", " ####", "    #", " ### "}},
    {'z', {"     ", "     ", "#####", "   # ", "  #  ", " #   ", "#####"}},
};
// clang-format on

const Glyph* glyph_of(char code) {
  for (const Glyph& glyph : kGlyphs) {
    if (glyph.code == code) return &glyph;
  }
  return nullptr;
}

}  // namespace

int text_width(const char* text) { return static_cast<int>(std::strlen(text)) * kGlyphAdvance; }

void draw_text(Canvas& canvas, int x, int y, const char* text, uint16_t colour) {
  for (const char* c = text; *c != '\0'; ++c, x += kGlyphAdvance) {
    const Glyph* glyph = glyph_of(*c);
    if (glyph == nullptr) continue;  // a character the face lacks leaves a gap
    for (int row = 0; row < kGlyphHeight; ++row) {
      for (int column = 0; column < kGlyphWidth; ++column) {
        if (glyph->rows[row][column] != '#') continue;
        fill_rect(canvas, x + column * kFontScale, y + row * kFontScale, kFontScale, kFontScale, colour);
      }
    }
  }
}

}  // namespace ui
